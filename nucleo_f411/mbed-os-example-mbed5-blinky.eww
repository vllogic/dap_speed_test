<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$/mbed-os-example-mbed5-blinky.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>